# Keil uVision project lang.uvprojx, settings and files
target Cortex-M0 (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: lang_cm0 (library)
  AfterMake: cmd.exe /C copy .keil\Objects\lang_cm0.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: Allocator.h Array.h ArrayMap.h ArrayMapPrototype.cpp ArrayMapPrototype.h ArrayPrototype.cpp ArrayPrototype.h ArrayQueue.h ArrayQueuePrototype.cpp ArrayQueuePrototype.h BiConsumer.h BiConsumerEvent.h Boolean.cpp Boolean.h Buffer.h Byte.cpp Byte.h ByteBuffer.cpp ByteBuffer.h Bytes.cpp Bytes.h Character.cpp Character.h Class.h Closeable.h Collection.h CompletionHandler.h Consumer.h ConsumerEvent.h Data.cpp Data.h EmptyReadBuffer.cpp EmptyReadBuffer.h EmptyWriteBuffer.cpp EmptyWriteBuffer.h EntryPoint.cpp EntryPoint.h ErrorCode.h Function.h FunctionEvent.h Future.cpp Future.h HashGen.cpp HashGen.h InputStream.cpp InputStream.h InputStreamBuffer.cpp InputStreamBuffer.h Integer.cpp Integer.h Integers.cpp Integers.h Interface.h Kernel.h Map.h Maths.cpp Maths.h Memory.cpp Memory.h Number.cpp Number.h Object.cpp Object.h OutputStream.cpp OutputStream.h OutputStreamBuffer.cpp OutputStreamBuffer.h package-info.h Pointer.cpp Pointer.h Pointers.cpp Pointers.h Pool.h PrintBuffer.cpp PrintBuffer.h Queue.h ReadBuffer.h README.md ReadOnlyBuffer.cpp ReadOnlyBuffer.h RingBuffer.cpp RingBuffer.h Runnable.h RunnableEntity.cpp RunnableEntity.h RunnableEvent.cpp RunnableEvent.h Short.cpp Short.h Shorts.cpp Shorts.h Stacker.cpp Stacker.h StreamSkipper.cpp StreamSkipper.h StringFormat.cpp StringFormat.h Strings.cpp Strings.h Supplier.h SupplierEvent.h Svchost.cpp Svchost.h System.cpp System.h Thread.cpp Thread.h ThreadPriority.h ThreadState.h Updater.h WriteBuffer.h
target Cortex-M3 (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: lang_cm3 (library)
  AfterMake: cmd.exe /C copy .keil\Objects\lang_cm3.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex-M4F (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: lang_cm4f (library)
  AfterMake: cmd.exe /C copy .keil\Objects\lang_cm4f.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
