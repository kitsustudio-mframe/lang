# Keil uVision project keil.uvprojx, settings and files
target lang_cm0 (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: lang_cm0 (library)
  AfterMake: .keil\copy.bat lang_cm0.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F415RBT7
  c include: ..\*\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: Allocator.h Array.h ArrayPrototype.cpp ArrayPrototype.h ArrayQueue.h ArrayQueuePrototype.cpp ArrayQueuePrototype.h BiConsumer.h BiConsumerEvent.h Buffer.h Closeable.h Collection.h CompletionHandler.h Consumer.h ConsumerEvent.h Data.cpp Data.h ErrorCode.h Function.h FunctionEvent.h Future.cpp Future.h InputStream.h InputStreamBuffer.h Interface.h Kernel.h Maths.cpp Maths.h Memory.cpp Memory.h Object.cpp Object.h OutputStream.h OutputStreamBuffer.h package-info.h Pointer.h ReadBuffer.h README.md ReadOnlyBuffer.cpp ReadOnlyBuffer.h RingBuffer.cpp RingBuffer.h RingBufferInputStream.cpp RingBufferInputStream.h RingBufferOutputStream.cpp RingBufferOutputStream.h Runnable.h RunnableEntity.cpp RunnableEntity.h RunnableEvent.cpp RunnableEvent.h Stacker.cpp Stacker.h StreamSkipper.cpp StreamSkipper.h Strings.cpp Strings.h Supplier.h SupplierEvent.h Svchost.cpp Svchost.h System.cpp System.h Thread.h ThreadPriority.h ThreadState.h WriteBuffer.h Updater.h Queue.h
target lang_cm3 (6180000::V6.18::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: lang_cm3 (library)
  AfterMake: .keil\copy.bat lang_cm3.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target lang_cm4f (6180000::V6.18::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: lang_cm4f (library)
  AfterMake: .keil\copy.bat lang_cm4f.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
